<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\class_proj.ewp</path>
  </project>
  <batchBuild />
</workspace>
